inherit kernel_save_defconfig